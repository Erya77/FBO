# Keil uVision project DM8_V3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P642 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\EMWIN\STemWinLibrary522\Config;..\EMWIN\STemWinLibrary522\inc;..\MALLOC;..\HARDWARE\KEY;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\HARDWARE\IIC;..\USER;..\EMWIN_DEMO\GUIBulder;..\HARDWARE\DISPOSE;..\HARDWARE\DEPLOY;..\HARDWARE\EXTI;..\HARDWARE\ADC;..\SYSTEM\softTimer;..\HARDWARE\pca9554;..\HARDWARE\TCA6424A;..\HARDWARE\XMOS_ADC;..\HARDWARE\DISPLAY;..\STM32F10x_FWLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LCD/: logo.c QR_code.c ILI9341.c weiruan24.c
    ../HARDWARE/DISPOSE/: dispose.c
    ../HARDWARE/DEPLOY/: deploy.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/pca9554/: pca9554.c
    ../HARDWARE/TCA6424A/: tca6424a.c
    ../HARDWARE/XMOS_ADC/: xmos_adc.c
    ../HARDWARE/DISPLAY/: display.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/softTimer/: softTimer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_dma.c
  group STENWIN
    ../EMWIN/STemWinLibrary522/Config/: GUIConf.h GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c fbo.c
    ../EMWIN/STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
    ../EMWIN/STemWinLibrary522/OS/: GUI_X.c
  group MALLOC
    ../MALLOC/: malloc.c
  group readme
    ./: readme.txt
